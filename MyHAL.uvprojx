# Keil uVision project MyHAL.uvprojx, settings and files
target Target_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MyHAL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ON_TARGET
  c include: .\test\support;.\src\stm32cube_files;.\src\stm32cube_files\App;.\src\stm32cube_files\core;.\src\stm32cube_files\middlewares;.\src\stm32cube_files\middlewares\option;.\src\stm32cube_files\Target;.\src;C:\Keil_v5\ARM\PACK\Keil\STM32F0xx_DFP\2.1.1\Drivers\STM32F0xx_HAL_Driver\Inc;.\RTE\Device\STM32F031K6Tx;src\RTC;src\led;src\sd_card;src\serial_snooper;src\dip_switch;src\circular_buffer;src\cli;src\common
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MyApplication
    ./src/common/: MyCommon.c Loop.c
    ./src/cli/: MyReceiver.c MyUSART.c MyProcessor.c MyTerminalUART.c MyCLI.c
    ./src/led/: MyGPIO.c LED.c
    ./src/: MyApp.c
    ./src/sd_card/: MySD.c
    ./src/dip_switch/: MyDipSwitch.c AppDecider.c BaudDecider.c
    ./src/serial_snooper/: SerialSnooper.c
    ./src/circular_buffer/: MyCircularBuffer.c
    ./src/rtc/: MyTimeString.c MyRTC.c
  group Debug
    ./: retarget.c
  group stm32cube_files
    ./src/stm32cube_files/: user_diskio_spi.c
    ./src/stm32cube_files/Target/: user_diskio.c
    ./src/stm32cube_files/middlewares/: diskio.c ff.c ff_gen_drv.c
    ./src/stm32cube_files/middlewares/option/: syscall.c unicode.c
    ./src/stm32cube_files/App/: fatfs.c
    ./src/stm32cube_files/core/: stm32f0xx_hal_msp.c stm32f0xx_it.c main_fatfs.c
  group STM32_HAL
    C:/Keil_v5/ARM/PACK/Keil/STM32F0xx_DFP/2.1.1/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi.c stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
